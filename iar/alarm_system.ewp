# IAR project alarm_system.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C6 ST STM32F030C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\nickh\Desktop\embedded\alarm system\drivers\inc; C:\Users\nickh\Desktop\embedded\alarm system\drivers\startup; C:\Users\nickh\Desktop\embedded\alarm system\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\nickh\Desktop\embedded\alarm system\drivers\startup\stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: alarm_system.srec
  group drivers/inc
    ../drivers/inc/: gpio_driver.h i2c_driver.h lcd.h rcc_driver.h spi_driver.h stm32f030.h timers.h
  group drivers/src
    ../drivers/src/: gpio_driver.c i2c_driver.c lcd.c rcc_driver.c spi_driver.c timers.c
  group drivers/startup
    ../drivers/startup/: startup.c startup.h startup_stm32f030x6.s stm32f030x6_flash.icf
  group inc
    ../inc/: all_inits.h buzzer.h display.h init_system_states.h main.h tmp75.h
  group src
    ../src/: all_inits.c buzzer.c display.c init_system_states.c interrupts.c main.c tmp75.c
